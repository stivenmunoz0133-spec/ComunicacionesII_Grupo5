options:
  parameters:
    author: 'Grupo 5: Elkin Largo, Stiven Muñoz, Minuk Lee'
    comment: GRC para analizar ruido AWGN en modulaciones basadas en constelaciones
    description: 'Osmocom Source -> desplazamiento LO -> remuestreo 2 MS/s x 16/125 = 256 kS/s (bb_rate) -> AGC -> filtro acoplado -> Symbol Sync (Gardner) -> Costas (orden 2) -> decision. Ambiguedad de fase 180 grados de BPSK: los bits pueden salir invertidos; se resuelve con secuencia conocida.'
    generate_options: qt_gui
    id: S3_BPSK_Grupo5_HackRF_RX
    output_language: python
    title: S3 BPSK Grupo 5 - RX HackRF One (Fase 3, NO validado en hardware)
  states: {}

blocks:
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: h_mf
  id: variable
  parameters:
    value: '[1.0/Sps]*Sps'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    comment: Cambie esta tabla para OOK ASK BPSK QPSK 8PSK o 16QAM
    value: (-1+0j, 1+0j)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: fc
  id: variable
  parameters:
    value: 960e6
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: interp_hw
  id: variable
  parameters:
    value: '125'
  states: {}
- name: decim_hw
  id: variable
  parameters:
    value: '16'
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: hackrf_rx
    bb_gain0: rx_vga
    comment: fc y ganancias tomadas del archivo de referencia del curso; verificar con el equipo real.
    freq0: fc + lo_off
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_lna
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: rx_bb
  id: rational_resampler_xxx
  parameters:
    comment: 2 MS/s x 16/125 = 256 kS/s
    decim: interp_hw
    interp: decim_hw
    type: ccc
  states: {}
- name: rx_lna
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rx_vga
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_agc
  id: analog_agc_xx
  parameters:
    type: complex
    rate: '1e-3'
    reference: '1.0'
    gain: '1.0'
    max_gain: '65536'
  states: {}
- name: rx_filtro_acoplado
  id: fir_filter_xxx
  parameters:
    type: ccf
    decim: '1'
    taps: h_mf
  states: {}
- name: rx_sync_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: cc
    ted_type: digital.TED_GARDNER
    sps: Sps
    ted_gain: '1.0'
    loop_bw: '0.01'
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: rx_costas
  id: digital_costas_loop_cc
  parameters:
    w: 2*math.pi/200
    order: '2'
  states: {}
- name: rx_real_decision
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: rx_decision
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: rx_espectro
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Rx radio
    name: '"Espectro recibido a radio_rate"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: rx_constelacion
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: '"Decision"'
    legend: 'False'
    name: '"Constelacion tras Symbol Sync + Costas"'
    size: '1024'
    type: complex
  states: {}
- name: rx_real_ojo
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: rx_ojo
  id: qtgui_eye_sink_x
  parameters:
    label1: Re{salida filtro acoplado}
    type: float
    ylabel: '"Amplitud"'
    size: '2048'
    samp_per_symbol: Sps
    srate: samp_rate
    grid: 'True'
    ymin: '-2'
    ymax: '2'
    entags: 'False'
    gui_hint: 2,0,1,1
    name: '"Diagrama de ojo (salida filtro acoplado, parte real)"'
  states: {}
- name: bits_rx_archivo
  id: blocks_file_sink
  parameters:
    file: '"bits_rx_hackrf.bin"'
    type: byte
  states: {}

connections:
- [hackrf_source, '0', rx_desplaza, '0']
- [rx_desplaza, '0', rx_bb, '0']
- [rx_bb, '0', rx_agc, '0']
- [rx_agc, '0', rx_filtro_acoplado, '0']
- [rx_filtro_acoplado, '0', rx_sync_simbolo, '0']
- [rx_sync_simbolo, '0', rx_costas, '0']
- [rx_costas, '0', rx_real_decision, '0']
- [rx_real_decision, '0', rx_decision, '0']
- [rx_desplaza, '0', rx_espectro, '0']
- [rx_costas, '0', rx_constelacion, '0']
- [rx_filtro_acoplado, '0', rx_real_ojo, '0']
- [rx_real_ojo, '0', rx_ojo, '0']
- [rx_decision, '0', bits_rx_archivo, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
