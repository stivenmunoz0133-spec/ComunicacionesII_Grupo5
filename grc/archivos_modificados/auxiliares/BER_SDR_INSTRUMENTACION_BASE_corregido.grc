options:
  parameters:
    author: Comunicaciones II - E3T
    comment: Plantilla de instrumentación. Copie los dos Embedded Python Blocks, variables y Vector Sink al GRC de su sistema.
    description: 'Instrumentación BER vs Eb/N0 para sistemas SDR funcionales con USRP o HackRF. [Corregido por Grupo 5: parametros de e_BER_Curve ligados a las variables.]'
    generate_options: qt_gui
    id: BER_SDR_INSTRUMENTACION_BASE
    output_language: python
    title: BER SDR - Instrumentación base
  states: {}

blocks:
- name: EbN0_max
  id: variable
  parameters:
    value: '14.0'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: EbN0_step
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: N_EbN0
  id: variable
  parameters:
    value: int(round((EbN0_max-EbN0_min)/EbN0_step))+1
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '64000.0'
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: '256000.0'
  states: {}
- name: bits_guardia
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: bits_por_punto
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: delay_bits
  id: variable
  parameters:
    value: '0'
  states: {}
- name: update_every
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: curva_ber
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: '"BER"'
    name: '"Curva BER experimental vs Eb/N0"'
    update_time: '0.2'
    vlen: N_EbN0
    width1: '3'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: EbN0_min
    x_step: EbN0_step
    x_units: '"dB"'
    y_axis_label: '"log10(BER)"'
    ymax: '0'
    ymin: '-7'
  states: {}
- name: e_BER_Curve
  id: epy_block
  parameters:
    _source_code: |
      """
      e_BER_Curve
      Acumulador de curva BER para los sistemas de los estudiantes.

      Entrada 0 : bits transmitidos de referencia (byte 0/1).
      Entrada 1 : bits recuperados por el receptor (byte 0/1).

      Salida 0  : vector BER lineal.
      Salida 1  : vector log10(BER) para QT GUI Vector Sink.

      El bloque usa exactamente el mismo barrido que e_EbN0_Sweep. Para cada punto:
      - ignora bits_guardia al comienzo del segmento;
      - compara bits_por_punto;
      - cuando el barrido vuelve a un punto, sigue acumulando estadísticas.

      delay_bits retrasa internamente la referencia Tx para compensar el retardo
      del receptor. Se ajusta primero en una condición limpia hasta lograr BER≈0.

      Cuando todavía no se observa ningún error, la salida logarítmica utiliza
      3/N como cota superior aproximada para poder mostrar el punto sin afirmar
      que BER=0.
      """

      import numpy as np
      from collections import deque
      from gnuradio import gr


      class blk(gr.decim_block):  # CORRECCION G5: gr.sync_decimator no es bloque Python en GR 3.10
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       delay_bits=0,
                       update_every=1000):
              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.delay_bits = max(0, int(delay_bits))
              self.update_every = max(1, int(update_every))

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.N = len(self.eb_axis)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              gr.decim_block.__init__(
                  self,
                  name='e_BER_Curve',
                  in_sig=[np.int8, np.int8],
                  out_sig=[(np.float32, self.N), (np.float32, self.N)],
                  decim=self.update_every
              )

              self.tx_fifo = deque([0]*self.delay_bits)
              self.raw_items = 0
              self.valid_bit_index = 0

              self.count = np.zeros(self.N, dtype=np.int64)
              self.errors = np.zeros(self.N, dtype=np.int64)

          def _process(self, tx, rx):
              for t, r in zip(tx, rx):
                  tb = int(t) & 1
                  rb = int(r) & 1

                  if self.delay_bits > 0:
                      self.tx_fifo.append(tb)
                      t_aligned = self.tx_fifo.popleft()
                      if self.raw_items < self.delay_bits:
                          self.raw_items += 1
                          continue
                  else:
                      t_aligned = tb

                  bit_index = self.valid_bit_index
                  segment_index = bit_index // self.segment_bits
                  point_index = segment_index % self.N
                  pos = bit_index % self.segment_bits

                  # Dejar que filtros/sincronizadores se estabilicen después
                  # del cambio de nivel de ruido.
                  if pos >= self.bits_guardia:
                      self.count[point_index] += 1
                      if t_aligned != rb:
                          self.errors[point_index] += 1

                  self.valid_bit_index += 1
                  self.raw_items += 1

          def _vectors(self):
              ber = np.zeros(self.N, dtype=np.float32)
              logber = np.zeros(self.N, dtype=np.float32)

              for i in range(self.N):
                  n = int(self.count[i])
                  e = int(self.errors[i])

                  if n <= 0:
                      ber[i] = 0.0
                      logber[i] = 0.0
                  elif e > 0:
                      b = e/float(n)
                      ber[i] = b
                      logber[i] = np.log10(max(b, 1e-12))
                  else:
                      # BER observado = 0; para la gráfica usamos una cota superior.
                      ber[i] = 0.0
                      upper = min(1.0, 3.0/float(n))
                      logber[i] = np.log10(max(upper, 1e-12))

              return ber, logber

          def work(self, input_items, output_items):
              tx = input_items[0]
              rx = input_items[1]
              out_ber = output_items[0]
              out_log = output_items[1]

              nout = len(out_ber)
              D = self.update_every

              for k in range(nout):
                  a = k*D
                  b = min((k+1)*D, len(tx))
                  if a < b:
                      self._process(tx[a:b], rx[a:b])

                  ber, logber = self._vectors()
                  out_ber[k, :] = ber
                  out_log[k, :] = logber

              return nout
    EbN0_min: EbN0_min
    EbN0_max: EbN0_max
    EbN0_step: EbN0_step
    bits_por_punto: bits_por_punto
    bits_guardia: bits_guardia
    delay_bits: delay_bits
    update_every: update_every
  states: {}
- name: e_EbN0_Sweep
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      """
      e_EbN0_Sweep
      Instrumento para caracterización BER con un enlace SDR ya funcional.

      Entrada 0 : señal compleja I/Q recibida del SDR (preferiblemente DESPUÉS
                  de la adaptación radio_rate -> bb_rate).
      Salida 0  : la misma señal I/Q con AWGN adicional controlado.
      Salida 1  : valor instantáneo de Eb/N0 [dB] usado en el barrido.

      El bloque NO sustituye el USRP/HackRF ni el receptor. Se inserta entre
      la salida I/Q del SDR y la entrada del receptor digital.

      El barrido se hace por segmentos contiguos. Cada punto se mantiene durante:
          bits_guardia + bits_por_punto

      La potencia de ruido artificial se calcula a partir de la potencia promedio
      medida ANTES de agregar el ruido:

          Eb = Ps / Rb
          N0 = Eb / (Eb/N0)
          Pn = N0 * Fs

      por lo tanto:

          Pn = Ps * Fs / (Rb * 10**(EbN0_dB/10))

      El ruido complejo se genera con varianza total Pn.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       samp_rate=256000.0,
                       bit_rate=64000.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       signal_power=0.0,
                       seed=2026):
              gr.sync_block.__init__(
                  self,
                  name='e_EbN0_Sweep',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32]
              )

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.samp_rate = float(samp_rate)
              self.bit_rate = float(bit_rate)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.signal_power_cfg = float(signal_power)

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.samp_rate <= 0 or self.bit_rate <= 0:
                  raise ValueError("samp_rate y bit_rate deben ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              self.sample_count = 0
              self.power_sum = 0.0
              self.power_count = 0
              self.rng = np.random.default_rng(int(seed))

          def _signal_power(self, x):
              if self.signal_power_cfg > 0:
                  return self.signal_power_cfg

              # Promedio acumulado de la señal recibida ANTES del ruido artificial.
              self.power_sum += float(np.sum(np.abs(x.astype(np.complex128))**2))
              self.power_count += len(x)
              if self.power_count <= 0:
                  return 0.0
              return max(self.power_sum/self.power_count, 1e-20)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              eb_out = output_items[1]
              n = len(x)
              if n == 0:
                  return 0

              Ps = self._signal_power(x)

              # Índice absoluto de muestra -> índice equivalente de bit.
              s = self.sample_count + np.arange(n, dtype=np.float64)
              bit_index = np.floor(s*self.bit_rate/self.samp_rate).astype(np.int64)

              segment_index = bit_index // self.segment_bits
              point_index = np.mod(segment_index, len(self.eb_axis))
              ebn0_db = self.eb_axis[point_index]
              ebn0_lin = np.power(10.0, ebn0_db/10.0)

              # Potencia total del ruido complejo por muestra.
              noise_power = Ps*self.samp_rate/(self.bit_rate*ebn0_lin)
              sigma_iq = np.sqrt(np.maximum(noise_power, 0.0)/2.0)

              noise = (
                  self.rng.standard_normal(n)*sigma_iq
                  + 1j*self.rng.standard_normal(n)*sigma_iq
              ).astype(np.complex64)

              y[:] = x + noise
              eb_out[:] = ebn0_db.astype(np.float32)

              self.sample_count += n
              return n
    bit_rate: Rb
    bits_guardia: bits_guardia
    bits_por_punto: bits_por_punto
    samp_rate: bb_rate
    seed: '2026'
    signal_power: '0.0'
  states: {}
- name: e_BER_CSV
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from pathlib import Path
      import csv
      import time


      class blk(gr.sync_block):

          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       nombre_archivo="curva_BER.csv",
                       guardar_cada=2.0):

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)

              self.N = int(round(
                  (self.EbN0_max - self.EbN0_min) /
                  self.EbN0_step
              )) + 1

              gr.sync_block.__init__(
                  self,
                  name='Guardar curva BER en CSV',
                  in_sig=[
                      (np.float32, self.N),
                      (np.float32, self.N)
                  ],
                  out_sig=None
              )

              self.nombre_archivo = str(nombre_archivo)
              self.guardar_cada = float(guardar_cada)

              # El Embedded Python Block se genera junto al flowgraph de GNU Radio.
              # Por ello el CSV queda en la misma carpeta contenedora del .grc/.py.
              try:
                  self.carpeta = Path(__file__).resolve().parent
              except NameError:  # CORRECCION G5: GRC instancia el bloque sin __file__ al validarlo
                  self.carpeta = Path.cwd()
              self.ruta_csv = self.carpeta / self.nombre_archivo

              self.ultimo_guardado = 0.0
              self.ebn0 = self.EbN0_min + self.EbN0_step * np.arange(self.N)

              print("CSV BER se guardará en:")
              print(self.ruta_csv)

          def guardar(self, ber, logber):
              archivo_temporal = self.ruta_csv.with_suffix(".tmp")

              with open(archivo_temporal, "w", newline="", encoding="utf-8") as f:
                  writer = csv.writer(f)
                  writer.writerow(["EbN0_dB", "BER", "log10_BER"])

                  for eb, b, lb in zip(self.ebn0, ber, logber):
                      writer.writerow([
                          f"{eb:.6f}",
                          f"{float(b):.12e}",
                          f"{float(lb):.12e}"
                      ])

              archivo_temporal.replace(self.ruta_csv)

          def work(self, input_items, output_items):
              ber_vectors = input_items[0]
              log_vectors = input_items[1]

              if len(ber_vectors) == 0:
                  return 0

              ahora = time.time()
              if ahora - self.ultimo_guardado >= self.guardar_cada:
                  self.guardar(ber_vectors[-1], log_vectors[-1])
                  self.ultimo_guardado = ahora

              return len(ber_vectors)
    comment: Guarda automáticamente la curva BER actual en curva_BER.csv.
    guardar_cada: '2.0'
    nombre_archivo: '"curva_BER.csv"'
  states: {}

connections:
- [e_BER_Curve, '1', curva_ber, '0']
- [e_BER_Curve, '0', e_BER_CSV, '0']
- [e_BER_Curve, '1', e_BER_CSV, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
